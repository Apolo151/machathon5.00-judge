Commit message: added camera script and modified world

File: prius_description/urdf/prius.urdf (robot description, URDF)
Before this commit: robot prius, 12 links, 11 joints
Joints:
- joint front_camera_joint: origin xyz=0 -0.9 1.1 rpy=0 0 -1.5707 -> xyz=0 -1.7 1.3 rpy=0 0 -1.5707
